## package/agent/Config.in
```kconfig
config BR2_PACKAGE_AGENT
	bool "agent"
	default n
	help
	  Confidential Distributed Computing Agent
```
